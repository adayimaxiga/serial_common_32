# Keil uVision project JudgementSerial.uvprojx, settings and files
target JudgementSerial (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: JudgementSerial
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F405xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;         ../Drivers/STM32F4xx_HAL_Driver/Inc;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;         ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Drivers/CMSIS/Include;         ..\XJTURMlib;         ..\app; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: freertos.c gpio.c usart.c dma.c stm32f4xx_it.c main.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c croutine.c queue.c timers.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_dma.c stm32f4xx_ll_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f405xx.h
  group Application/XJTURMlib
    ../XJTURMlib/: data_fifo.c pid.c protocol.c
  group Application/UserTask
    ../app/: task_communicate.c
    ../: README.md
  group Application/UserBsp
    ../Src/: bsp_usart.c
software components: CMSIS:CORE 4.1.0
